Commit message: fix rviz and urdf

File: urdf/orcahand_right.urdf (robot description, URDF)
Before this commit: robot orcahand_right, 42 links, 41 joints
Joints:
- joint world2right_tower_fixed: origin xyz=0.04 0.0 0.04575 rpy=0.0 0.0 0.0 -> xyz=-0.04 0.0 0.04575 rpy=0.0 0.0 0.0
